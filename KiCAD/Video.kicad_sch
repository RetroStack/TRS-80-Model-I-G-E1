File: KiCAD/Video.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Updated revision to Rev C
Other:
- title: TRS-80 Model I G -> TRS-80 Model I Rev G
