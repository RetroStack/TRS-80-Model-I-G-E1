File: KiCAD/Clock.kicad_sch (KiCad schematic)
At the start: 5 parts, among them Y1 10.6445 MHz

Commit message: Updated revision to Rev C
Other:
- title: TRS-80 Model I G -> TRS-80 Model I Rev G
